# IAR project Project.ewp, settings and files
configuration B-L4S5I-IOT01_2_Images_SBSFU (ARM)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; USE_STM32L475E_IOT01; KMS_ENABLED; MBEDTLS_CONFIG_FILE=<sfu_scheme_x509_config_mbedtls.h>; ENABLE_IMAGE_STATE_HANDLING
  ICCARM.CCIncludePath2: ../Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\Core\Inc; ..\SBSFU\App; ..\SBSFU\Target; ..\..\2_Images_SECoreBin\Inc; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Interface; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\tKMS; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Interface; ..\..\..\..\..\..\Middlewares\Third_Party\MbedTLS\include; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32L4\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "$PROJ_DIR$.\se_interface_appli.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: SE_CORE_Bin; SE_UserHandlerWrapper
  ILINK.IlinkIcfFile: stm32l4S5xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/Core
    ../Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_loader.c sfu_boot.c sfu_com_loader.c sfu_com_trace.c sfu_error.c sfu_test.c sfu_fwimg_core.c sfu_fwimg_services.c sfu_new_image.c sfu_scheme_x509_mbedtls_ecdsa_verify.c sfu_scheme_x509_core.c sfu_scheme_x509_crt.c sfu_scheme_x509_if.c sfu_kms.c
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level.c sfu_low_level_flash.c sfu_low_level_security.c
  group Application/EWARM
    ./: startup_stm32l4S5xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c
  group Drivers/BSP/B-L4S5I-IOT01A
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c se_interface_exception_IAR.s
  group Middlewares/STM32_Key_Management_Services
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/tKMS/: se_interface_kms.c tkms.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
