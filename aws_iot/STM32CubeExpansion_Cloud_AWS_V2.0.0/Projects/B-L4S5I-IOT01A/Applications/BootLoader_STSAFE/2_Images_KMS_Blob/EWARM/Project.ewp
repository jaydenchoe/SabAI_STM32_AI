# IAR project Project.ewp, settings and files
configuration B-L4S5I-IOT01_2_Images_KMS_Blob (ARM)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; SENSOR
  ICCARM.CCIncludePath2: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/BSPv2/B-L475E-IOT01; ../Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Platform; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32L4\Middlewares\ST\STM32_Cryptographic\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32L4\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\KMS_Blob.bin
  postbuild: cmd /C "cmd /C postbuild.bat "$PROJ_DIR$" "KMS_Blob" 1 "
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l4S5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: kms_blob_example_keys.c
